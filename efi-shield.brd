# Repository cpsmv/hardware (continued)

## EAGLE design efi-shield.brd (continued)

Board: 2 copper layers, 162 parts (0 on the bottom side), 87 nets, no tracks yet.

Other parts of the board:
U$2: CPSMV_FRAME

File efi-shield_BOM.csv (part):

"Part";"Value";"Device";"Package";"Description";"DATASHEET_LINK";"LED_COLOR";"MANUFACTURER";"MANUFACTURER_PN";"PACKAGE";"SUPPLIER";"SUPPLIER_PN";
"C1";"0.1uF";"CAP-JKE";"C050-025X075";"Axial lead, through-hole, general purpose capacitor";"http://www.joeknowselectronics.com/index.php/products/compon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";"";"joe Knows Electronics";"n/a";"C050-025X075";"Joe knows Electronics";"n/a";
"C2";"0.1uF";"CAP-JKE";"C050-025X075";"Axial lead, through-hole, general purpose capacitor";"http://www.joeknowselectronics.com/index.php/products/compon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";"";"joe Knows Electronics";"n/a";"C050-025X075";"Joe knows Electronics";"n/a";
"C3";"10nF";"CAP-JKE";"C050-025X075";"Axial lead, through-hole, general purpose capacitor";"http://www.joeknowselectronics.com/index.php/products/compon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";"";"joe Knows Electronics";"n/a";"C050-025X075";"Joe knows Electronics";"n/a";
"C4";"47nF";"CAP-JKE";"C050-025X075";"Axial lead, through-hole, general purpose capacitor";"http://www.joeknowselectronics.com/index.php/products/compon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";"";"joe Knows Electronics";"n/a";"C050-025X075";"Joe knows Electronics";"n/a";
"C5";"10nF";"CAP-JKE";"C050-025X075";"Axial lead, through-hole, general purpose capacitor";"http://www.joeknowselectronics.com/index.php/products/compon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";"";"joe Knows Electronics";"n/a";"C050-025X075";"Joe knows Electronics";"n/a";
"C6";"47nF";"CAP-JKE";"C050-025X075";"Axial lead, through-hole, general purpose capacitor";"http://www.joeknowselectronics.com/index.php/products/compon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";"";"joe Knows Electronics";"n/a";"C050-025X075";"Joe knows Electronics";"n/a";
"C7";"330pF";"CAP-JKE";"C050-025X075";"Axial lead, through-hole, general purpose capacitor";"http://www.joeknowselectronics.com/index.php/products/compon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";"";"joe Knows Electronics";"n/a";"C050-025X075";"Joe knows Electronics";"n/a";
"C8";"330pF";"CAP-JKE";"C050-025X075";"Axial lead, through-hole, general purpose capacitor";"http://www.joeknowselectronics.com/index.php/products/compon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";"";"joe Knows Electronics";"n/a";"C050-025X075";"Joe knows Electronics";"n/a";
"C9";"330pF";"CAP-JKE";"C050-025X075";"Axial lead, through-hole, general purpose capacitor";"http://www.joeknowselectronics.com/index.php/products/compon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";"";"joe Knows Electronics";"n/a";"C050-025X075";"Joe knows Electronics";"n/a";
"C10";"220pF";"CAP-JKE";"C050-025X075";"Axial lead, through-hole, general purpose capacitor";"http://www.joeknowselectronics.com/index.php/products/compon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";"";"joe Knows Electronics";"n/a";"C050-025X075";"Joe knows Electronics";"n/a";
"C13";"6.8nF";"CAP-JKE";"C050-025X075";"Axial lead, through-hole, general purpose capacitor";"http://www.joeknowselectronics.com/index.php/products/compon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";"";"joe Knows Electronics";"n/a";"C050-025X075";"Joe knows Electronics";"n/a";
"C14";"10nF";"CAP-JKE";"C050-025X075";"Axial lead, through-hole, general purpose capacitor";"http://www.joeknowselectronics.com/index.php/products/compon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";"";"joe Knows Electronics";"n/a";"C050-025X075";"Joe knows Electronics";"n/a";
"C15";"330pF";"CAP-JKE";"C050-025X075";"Axial lead, through-hole, general purpose capacitor";"http://www.joeknowselectronics.com/index.php/products/compon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";"";"joe Knows Electronics";"n/a";"C050-025X075";"Joe knows Electronics";"n/a";
"C16";"10nF";"CAP-JKE";"C050-025X075";"Axial lead, through-hole, general purpose capacitor";"http://www.joeknowselectronics.com/index.php/products/compon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";"";"joe Knows Electronics";"n/a";"C050-025X075";"Joe knows Electronics";"n/a";
"C17";"330pF";"CAP-JKE";"C050-025X075";"Axial lead, through-hole, general purpose capacitor";"http://www.joeknowselectronics.com/index.php/products/compon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";"";"joe Knows Electronics";"n/a";"C050-025X075";"Joe knows Electronics";"n/a";
"C18";"10nF";"CAP-JKE";"C050-025X075";"Axial lead, through-hole, general purpose capacitor";"http://www.joeknowselectronics.com/index.php/products/compon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";"";"joe Knows Electronics";"n/a";"C050-025X075";"Joe knows Electronics";"n/a";
"C19";"330pF";"CAP-JKE";"C050-025X075";"Axial lead, through-hole, general purpose capacitor";"http://www.joeknowselectronics.com/index.php/products/compon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";"";"joe Knows Electronics";"n/a";"C050-025X075";"Joe knows Electronics";"n/a";
"C33";"0.1uF";"CAP-JKE";"C050-025X075";"Axial lead, through-hole, general purpose capacitor";"http://www.joeknowselectronics.com/index.php/products/compon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";"";"joe Knows Electronics";"n/a";"C050-025X075";"Joe knows Electronics";"n/a";
"C34";"4.7nF";"CAP-JKE";"C050-025X075";"Axial lead, through-hole, general purpose capacitor";"http://www.joeknowselectronics.com/index.php/products/compon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";"";"joe Knows Electronics";"n/a";"C050-025X075";"Joe knows Electronics";"n/a";
"C35";"2.2uF";"CAP-JKE";"C050-025X075";"Axial lead, through-hole, general purpose capacitor";"http://www.joeknowselectronics.com/index.php/products/compon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";"";"joe Knows Electronics";"n/a";"C050-025X075";"Joe knows Electronics";"n/a";
"C36";"2.2uF";"CAP-JKE";"C050-025X075";"Axial lead, through-hole, general purpose capacitor";"http://www.joeknowselectronics.com/index.php/products/compon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";"";"joe Knows Electronics";"n/a";"C050-025X075";"Joe knows Electronics";"n/a";
"D1";"GREEN";"LTL-533-11";"LED,THRU-HOLE,R/A";"LED, thru-hole, R/A, green";"http://optoelectronics.liteon.com/upload/download/DS-20-92-0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";"Green";"Lite-On";"LTL-533-11";"Through-hole LED, R/A";"Digi-Key";"160-1977-ND";
"D2";"YELLOW";"LTL-553-11";"LED,THRU-HOLE,R/A";"LED, thru-hole, R/A, yellow";"http://optoelectronics.liteon.com/upload/download/DS-20-92-0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";"Yellow";"Lite-On";"LTL-553-11";"Through-hole LED, R/A";"Digi-Key";"160-1978-ND";
"D3";"YELLOW";"LTL-553-11";"LED,THRU-HOLE,R/A";"LED, thru-hole, R/A, yellow";"http://optoelectronics.liteon.com/upload/download/DS-20-92-0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";"Yellow";"Lite-On";"LTL-553-11";"Through-hole LED, R/A";"Digi-Key";"160-1978-ND";
"D4";"RED";"LTL-523-11";"LED,THRU-HOLE,R/A";"LED, thru-hole, R/A, red";"http://optoelectronics.liteon.com/upload/download/DS-20-92-0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";"Red";"Lite-On";"LTL-523-11";"Through-hole LED, R/A";"Digi-Key";"160-1976-ND";
"D5";"RED";"LTL-523-11";"LED,THRU-HOLE,R/A";"LED, thru-hole, R/A, red";"http://optoelectronics.liteon.com/upload/download/DS-20-92-0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";"Red";"Lite-On";"LTL-523-11";"Through-hole LED, R/A";"Digi-Key";"160-1976-ND";
"J1";"PWMH";"PINHD-1X10";"1X10";"PIN HEADER";"http://www.joeknowselectronics.com/index.php/products/headers.html";"";"Joe Knows Electronics";"n/a";"1X10 Header Pin";"Joe Knows Electronics";"n/a";
"J2";"PWMI";"PINHD-1X8";"1X08";"PIN HEADER";"http://www.joeknowselectronics.com/index.php/products/headers.html";"";"Joe Knows Electronics";"n/a";"1X8 Header Pin";"Joe Knows Electronics";"n/a";
"J3";"COMM";"PINHD-1X8";"1X08";"PIN HEADER";"http://www.joeknowselectronics.com/index.php/products/headers.html";"";"Joe Knows Electronics";"n/a";"1X8 Header Pin";"Joe Knows Electronics";"n/a";
"J4";"PWR";"PINHD-1X8";"1X08";"PIN HEADER";"http://www.joeknowselectronics.com/index.php/products/headers.html";"";"Joe Knows Electronics";"n/a";"1X8 Header Pin";"Joe Knows Electronics";"n/a";
"J5";"ADCL";"PINHD-1X8";"1X08";"PIN HEADER";"http://www.joeknowselectronics.com/index.php/products/headers.html";"";"Joe Knows Electronics";"n/a";"1X8 Header Pin";"Joe Knows Electronics";"n/a";
"J6";"ADCH";"PINHD-1X8";"1X08";"PIN HEADER";"http://www.joeknowselectronics.com/index.php/products/headers.html";"";"Joe Knows Electronics";"n/a";"1X8 Header Pin";"Joe Knows Electronics";"n/a";
"J7";"AMPSEAL-23POS-HEADER";"AMPSEAL-23POS-HEADER";"AMPSEAL-HEADER-23POS-RA";"23 position male header, wire-to-board, sealing connector";"http://www.te.com/commerce/DocumentDelivery/DDEController?Ac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";"";"TE Connectivity";"776087-1";"AMPSEAL-HEADER-23POS-RA";"Digi-Key";"A107007-ND";
"J8";"SPI";"PINHD-2X3";"2X03";"PIN HEADER";"http://www.joeknowselectronics.com/index.php/products/headers.html";"";"Joe Knows Electronics";"n/a";"2X03 Header Pin";"Joe Knows Electronics";"n/a";
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